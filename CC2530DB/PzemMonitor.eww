<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\PzemMonitor.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>PzemMonitor</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>PzemMonitor</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>PzemMonitor</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>PzemMonitor</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


